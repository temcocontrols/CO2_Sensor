# Keil uVision project TEST01.uvproj, settings and files
target MKL15Z32xxx4 (ARM-ADS)
  device: MKL15Z32xxx4 Freescale
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: TEST01 +hex
  c flags: Optim=1 wLevel=2
  c include: ".\Static_Code\PDD";".\Static_Code\IO_Map";".\Sources";".\Generated_Code";".\Generated_Code";".\Project_Settings\Startup_Code";".\Sources"
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  group GeneratedCs
    ./Generated_Code/: AD1.c AS1.c AS2.c Cpu.c GPIO1.c PE_LDD.c TI1.c TU1.c TimerIntLdd1.c Vectors.c FLASH1.c GPIO2.c
    ./Sources/: Events.c main.c os.c flash.c modbus.c iic.c htu21.c crc.c PSENSOR.C lmp91051.c co2.c caculate.c aq.c
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
  group GeneratedHs
    ./Generated_Code/: AD1.h AS1.h AS2.h Cpu.h GPIO1.h IO_Map.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h TI1.h TU1.h TimerIntLdd1.h
    ./Static_Code/PDD/: ADC_PDD.h CMP_PDD.h COP_PDD.h DAC_PDD.h DMAMUX_PDD.h DMA_PDD.h FTFA_PDD.h GPIO_PDD.h I2C_PDD.h LPTMR_PDD.h MCM_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RTC_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h UART0_PDD.h UART_PDD.h
    ./Sources/: Events.h
    ./Static_Code/IO_Map/: MKL15Z4.h
